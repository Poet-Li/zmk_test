## config/boards/arm/poetli_test/Kconfig.board
```kconfig
# Copyright (c) 2021 @MangoIV
# SPDX-License-Identifier: MIT

config BOARD_POETLI_TEST
	bool "poetli_test"
	depends on SOC_NRF52840_QIAA
```
